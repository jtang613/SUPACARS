options:
  parameters:
    generate_options: qt_gui
    id: SUPACARS
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 131.725e6
  states: {}
- name: corr_thres
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.5'
  states: {}
- name: init_sample_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 126e3
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    start: '0'
    step: '1'
    stop: '40'
    value: '26'
  states: {}
- name: rx_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    start: '1'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    formatter: '0'
    gui_hint: 5,0,1,1
    label: 'Terminal 1 '
    type: string
    value: Raw Text Output
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    formatter: '0'
    gui_hint: 5,1,1,1
    label: 'Terminal 2 '
    type: string
    value: Parser Text Output
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: rx_volume
    samp_rate: init_sample_rate
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/init_sample_rate
    type: fff
  states: {}
- name: pyqt_text_output_0
  id: pyqt_text_output
  parameters:
    gui_hint: 6,0,1,1
  states: {}
- name: pyqt_text_output_0_0
  id: pyqt_text_output
  parameters:
    gui_hint: 6,1,1,1
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0,1,2
    label1: ''
    name: '"ACARS signal"'
    size: '48000'
    srate: samp_rate
    type: float
  states: {}
- name: supacars_acars_0
  id: supacars_acars
  parameters:
    corr_thres: corr_thres
    samp_rate: samp_rate
  states: {}
- name: supacars_acarsparser_0
  id: supacars_acarsparser
  parameters:
    api_key: ''
    db_request_mode: 'True'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: uhd.tune_request(center_freq, lo_off)
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rx_gain
    samp_rate: init_sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', pfb_arb_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', supacars_acars_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [pfb_arb_resampler_xxx_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
